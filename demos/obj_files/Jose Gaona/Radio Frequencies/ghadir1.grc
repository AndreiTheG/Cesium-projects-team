options:
  parameters:
    generate_options: qt_gui
    id: ghadir1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '60000000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '150'
    audio_stop: '160'
    chan_rate: '28000000'
    deviation: '750'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '150'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '314'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '101'
    gain: '1'
    high_cutoff_freq: '20000000  '
    low_cutoff_freq: '10000000 '
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '15000000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1000000'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '15000000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_const_vxx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_const_vxx_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_add_const_vxx_0_0, '0', low_pass_filter_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_add_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
