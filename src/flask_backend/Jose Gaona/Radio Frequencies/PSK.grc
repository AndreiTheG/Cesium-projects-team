options:
  parameters:
    generate_options: qt_gui
    id: PSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '32'
  states: {}
- name: analog_frequency_modulator_fc_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '50'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '1'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '2'
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '15000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: int
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: int
    out_type: complex
    symbol_table: '1'
  states: {}
- name: digital_msk_timing_recovery_cc_0
  id: digital_msk_timing_recovery_cc
  parameters:
    affinity: '500'
    alias: '5'
    gain: '1'
    limit: '2'
    osps: '4'
    sps: '10'
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'True'
    type: int
  states: {}
- name: qtgui_graphicoverlay_0
  id: qtgui_graphicoverlay
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: sc
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_1, '1']
- [analog_frequency_modulator_fc_1, '0', blocks_add_xx_0, '1']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_1, '0', analog_nbfm_tx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_abs_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_add_const_vxx_0, '0', analog_quadrature_demod_cf_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_1, '0', digital_msk_timing_recovery_cc_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_1, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_const_vxx_1, '0']
- [digital_msk_timing_recovery_cc_0, '0', blocks_multiply_xx_0, '1']
- [digital_msk_timing_recovery_cc_0, '1', analog_frequency_modulator_fc_1, '0']
- [digital_msk_timing_recovery_cc_0, '2', analog_frequency_modulator_fc_0, '0']
- [network_tcp_source_0, '0', blocks_abs_xx_0, '0']
- [qtgui_graphicoverlay_0, overlay, digital_chunks_to_symbols_xx_0, set_symbol_table]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
